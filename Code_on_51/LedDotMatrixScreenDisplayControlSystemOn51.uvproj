# Keil uVision project LedDotMatrixScreenDisplayControlSystemOn51.uvproj, settings and files
target Target (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LedDotMatrixScreenDisplayControlSystemOn51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceCode
    ./: main.c
